# Keil uVision project mecanum.uvprojx, settings and files
target mecanum (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\HARDWARE;..\SYSTEM;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\port;..\FreeRTOS\src;..\MyTasks;..\BSP;..\Drivers;..\Algorithm
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c freertos_demo.c freertos_demo.h main.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/: retarget_uart.c retarget_uart.h robot_state.c robot_state.h SPL_Delay.c SPL_Delay.h Timer.c Timer.h watchdog.c watchdog.h
  group HARDWARE
    ../HARDWARE/: buzzer.c buzzer.h Can.c Can.h Encoder.c Encoder.h Key.c Key.h LED.c LED.h PWM.c PWM.h Usartx.c Usartx.h
  group FreeRTOS/include
    ../FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
    ../FreeRTOS/: FreeRTOSConfig.h
  group FreeRTOS/port
    ../FreeRTOS/port/: heap_4.c port.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group MyTasks
    ../MyTasks/: CTRL.c CTRL.h Display.c Display.h IMU.c IMU.h Telemetry.c Telemetry.h Uart.c Uart.h
  group BSP
    ../BSP/: bsp_soft_i2c.c bsp_soft_i2c.h bsp_exti.c bsp_exti.h bsp_tick.c bsp_tick.h
  group Drivers
    ../Drivers/: icm20948.c icm20948.h OLED.c OLED.h OLED_Font.h
  group Algorithm
    ../Algorithm/: imu_fusion.c imu_fusion.h
